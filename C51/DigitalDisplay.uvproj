# Keil uVision project DigitalDisplay.uvproj, settings and files
target Target (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: DigitalDisplay +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: main.c
  group Header
    ./: STC15.h driver.h
